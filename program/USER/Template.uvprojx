# Keil uVision project Template.uvprojx, settings and files
target Robocon2020 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HEADER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: readme.txt
  group HEADER
    ../HEADER/: include.h readme.txt init.h actuator_control.h protocol.h sensor.h interrupt.h mission.h vect.h gyro.h my_math.h basial_move.h pid_control.h pid_parameter.h elmo.h m3508_control.h ANO_DT.h ANO_DT_User_Settings.h packet.h imu_data_decode.h
  group INIT
    ../INIT/: init.c readme.txt
  group INTERRUPT
    ../INTERRUPT/: interrupt.c readme.txt
  group PROTOCOL
    ../PROTOCOL/: protocol.c readme.txt elmo.c m3508_control.c ANO_DT.c
  group SENSOR
    ../SENSOR/: sensor.c readme.txt gyro.c imu_data_decode.c packet.c
  group ACTUATOR_CONTRL
    ../ACTUATOR_CONTRL/: actuator_control.c readme.txt
  group BASIAL_MOVE
    ../BASIAL_MOVE/: basial_move.c readme.txt
  group ALGORITHM
    ../ALGORITHM/: pid_control.c pid_parameter.c
  group MISSION
    ../MISSION/: mission.c readme.txt
